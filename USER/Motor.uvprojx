# Keil uVision project Motor.uvprojx, settings and files
target MOTOR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\OBJ;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\GPIO_INIT;..\LCD12864;..\KEY;..\MOTOR;..\FLASH\SPI;..\FLASH\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group GPIO_INIT
    ../GPIO_INIT/: gpio.c
  group KEY
    ../KEY/: input_key.c
  group LCD12864
    ../LCD12864/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ist7920.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_s1d15e06.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_72x40.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_2040x16.c u8x8_d_ssd1309.c u8x8_d_ssd1316.c u8x8_d_ssd1317.c u8x8_d_ssd1318.c u8x8_d_ssd1320.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st7511.c u8x8_d_st7528.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7571.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7586s_ymc240160.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_st75256.c u8x8_d_st75320.c u8x8_d_stdio.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c u8g2_user.c
  group MOTOR
    ../MOTOR/: steep.c
  group FLASH
    ../FLASH/SPI/: spi.c
    ../FLASH/W25QXX/: w25qxx.c
  group README
    ../README/: ReadMe.txt
